Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-10-27T11:18:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 27 11:18:13 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\dc1d659a-f238-479c-a0df-f5b3750cc4a6\c6c89480-a90b-4ca2-81cf-a6921a99f33c\ifc * Database version: 5507 * Database creation date: Mon Oct 27 11:18:12 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 27 11:18:13 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 27 11:18:13 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6871, Módulo_FINE_6870_6871_Nordecor_IFC:6871:329135
In: Nível 1
Type - Material: Metal - Alumínio - Preto, Plástico - PC - Transparente
Type - Cotas - Altura do spot: 35 mm; Altura módulo: 46 mm; Comprimento módulo: 120 mm; Diâmetro spot: 90 mm
Type - Dados - Data de atualização: 17/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: módulo de iluminação, plafon para trilho magnético FINE, OPI, LED, 9W, 2700K, 90º, branco, preto, iluminação difusa, diâmetro 90mm; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Módulo para trilho FINE OPI, acabamento preto, LED 9W 2700K 90º; Descrição UniFormat: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú/SC - Brasil; Modelo: 6871; Nome do tipo: 6871; Nota-chave: 26 56 33.19; Número MasterFormat: 26 56 33; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6871.png; Tipo de luminária: Distribuição Direta / Facho Amplo; Título MasterFormat: Spots e Luminárias de Trilho; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-para-trilho-fine-opi-9w-2-700k-irc97/
Type - Elétrico - Comentários de voltagem: DC48V; Lâmpada: LED
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Ângulo de abertura: 90 deg; Fluxo luminoso: 745 lm; IRC: 97; Potência: 9 W; Temperatura de cor: 2700 K
Type - Materiais e acabamentos - Difusor: Plástico - PC - Transparente; Módulo: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; F. Luminosa: 6871; Nome da família: Módulo_FINE_6870_6871_Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6871; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.0243813 m2; Volume: 0.0000477123 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Módulo_FINE_6870_6871_Nordecor_IFC: 6871; Família e tipo: Módulo_FINE_6870_6871_Nordecor_IFC: 6871; ID de tipo: Módulo_FINE_6870_6871_Nordecor_IFC: 6871; Tipo: Módulo_FINE_6870_6871_Nordecor_IFC: 6871
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
